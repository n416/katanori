# Repository n416/katanori (continued)

## KiCad design hardware/pcb/katanori61_audio/katanori61_audio.kicad_pcb

Parts:
C43: 1uF; C_0402_1005Metric
C44: 10uF; C_0603_1608Metric
C45: 0.1uF; C_0402_1005Metric
C101, C104, C105, C106, C112, C113, C133, C135, C137, C139, C143, C145, C146, C147, C148, C149, C150, C151, C152, C153, C154, C155, C156, C157, C158, C160, C170, C183, C188, C189, C190, C192, C219, C242, C243, C244: 100nF; C0402
C102, C103: 20pF; C0402
C114, C136, C140, C163, C171, C172, C173: 10uF; C0603
C119, C120, C121, C165: 22uF; C0805
C122, C123: 100nF; C0603_v2
C124: 47uF; C1206
C127, C128, C129: 10nF; C0402
C134, C138: 22uF; C0603
C141, C144, C187, C210, C217, C223: 1uF; C0402
C164: 120pF; C0402
C166: 100nF; C0603
C168, C169: 2.2uF; C0603
C174: 22pF; C0402
C301, C302: 100nF; C_0402_1005Metric
D101, D104, D106, D107, D110, D112, D118, D119: SLESDPSA0402V05; ESD-0402; LCSC C7496591
FB104, FB105, FB106, FB107: 600R; L0603
FB108, FB109: 120R; L0603
J16: XU316 JTAG; JTAG_TP_2x4_P2.54mm; not fitted
J21: RISER PWR; PinHeader_1x07_P2.54mm_Vertical
J22: RISER SIG; PinHeader_1x07_P2.54mm_Vertical
J23: SPK; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
L101: 0.47uH; L0805; LCSC C97014
L102: 1uH; L2016; LCSC C395545
Q103: LBSS138WT1G; SOT-323; LCSC C383201
Q104: S9013W; SOT-323; LCSC C2919788
R46, R47, R48: 10K; R_0402_1005Metric
R101, R125, R223, R228: 4.7K; R0402
R102, R106, R108, R130, R163, R210, R212: 100R; R0402
R103: 1M; R0402
R104: 680R; R0402
R105, R109, R114, R116, R117, R136, R141, R145, R148, R160, R170, R171, R172, R173, R178, R192, R193, R194, R195, R196, R197, R201, R202, R203, R204, R205, R209, R214, R246: 0R; R0402
R107, R111: 47K; R0402
R112: 3.3K; R0402
R115, R123, R124, R131: 10K; R0402
R120, R121, R122: 15K; R0603
R128, R129, R135: 470K; R0402
R139: 0R; R0603
R144, R156, R157: 22R; R0402
R146, R155, R159, R177, R208: 100K; R0402
R147: 22.1K; R0402
R154: 51K; R0402
R175, R182: 0R; R0805
R199, R200: 0R; R0603_v2
TP1: TXD0; TestPoint_Pad_D1.0mm
TP2: RXD0; TestPoint_Pad_D1.0mm
TP3: IO0; TestPoint_Pad_D1.0mm
TP4: EN; TestPoint_Pad_D1.0mm
U5: ESP32-S3-WROOM-1U-N16R8; ESP32-S3-WROOM-1U; LCSC C3013946
U102: XU316-1024-QF60B-C32; QFN_F60B-C24_XMO; LCSC C7397517
U103: W25Q32JVSSIQ; SOIC8-1.27-5.3X5.3MM; LCSC C179173
U104, U105: MSM261DHP006; MIC8P-0.85-4X3X1MM; LCSC C22390138
U106: SN74LVC125APWR; LCSC C7813
U108: TLV320AIC3204IRHBR; LCSC C24109
U109: TPA6211A1DGNR; DGN8_1d89X1P57; LCSC C7718
U110: TPS62827DMQR; DFN6-0.5-1.5X1.5X0.65MM; LCSC C2071448
U111: ME6211C18M5G-N; SOT-23-5; LCSC C236671
U112: TPS62065DSGR; DFN8G-0.5-2X2MM; LCSC C398352
U118: SGM2036S-3.3XXDH4G/TR; X2SON4-0.625-1x1x0.6mm; LCSC C5152997
X101: 24MHz 12pF; X4-SMD-2.0X1.6MM; LCSC C5265838

Connections:
3V3_EN: R208.1, U110.1 (EN)
3V3_PG: R177.1, U110.2 (PG)
AMP_CTL: C129.1, R125.1, R135.2, U109.1 (*SHUTDOWN)
AUDIO_PA_EN: R136.1, U5.24 (IO47)
BTN: J21.4, U5.33 (IO40)
ESP_BOOT: R47.2, TP3.1, U5.27 (IO0)
ESP_EN: C43.1, R46.2, TP4.1, U5.3 (EN)
ESP_RXD: TP2.1, U5.36 (RXD0)
ESP_TXD: TP1.1, U5.37 (TXD0)
ESP_USB_DN: R156.2, U5.13 (USB_D-)
ESP_USB_DP: R157.2, U5.14 (USB_D+)
GND: C43.2, C44.2, C45.2, C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C112.2, C129.2, C135.2, C136.2, C137.2, C138.2, C139.2, C140.2, C141.2, C143.2, C144.2, C145.2, C146.2, C147.2, C148.2, C149.2, C150.2, C151.2, C152.2, C153.2, C154.2, C155.2, C156.2, C157.2, C158.2, C160.2, C163.2, C165.2, C166.2, C168.2, C169.2, C170.2, C171.2, C172.2, C173.2, C183.2, C190.2, C192.2, C210.2, C217.2, C223.2, C242.2, C243.2, C244.2, C301.2, C302.2, D101.1, D104.1, D106.1, D107.1, D110.1, D112.1, D118.1, D119.1, J16.7, J21.2, J22.1, Q103.2 (S), Q104.2 (E), R48.2, R107.1, R111.1, R115.1, R129.1, R135.1, R147.1, R155.1, R175.1, R182.1, U5.1 (GND), U5.40 (GND), U5.41 (GND), U102.65 (GND), U103.4 (GND), U104.5 (GND1), U104.6 (GND2), U104.7 (GND3), U104.8 (GND4), U105.2 (L/R), U105.5 (GND1), U105.6 (GND2), U105.7 (GND3), U105.8 (GND4), U106.1 (1~OE), U106.2 (1A), U106.4 (2~OE), U106.7 (GND), U108.7 (IOVSS), U108.28 (DVSS), U108.33 (EP), U110.4 (GND), U111.2 (GND), U112.1 (PGND), U112.3 (AGND), U112.9 (PAD), U118.2 (GND), U118.5 (EP), X101.2, X101.4
GNDA: C113.2, C114.2, C121.1, C122.1, C123.2, C124.2, C127.2, C128.2, C133.2, C134.2, C187.2, C188.2, C189.2, C219.2, R175.2, R182.2, U108.17 (AVSS), U109.7 (GND), U109.EPAD
GPIO7: R193.2, U5.7 (IO7)
GPIO8: R194.2, U5.12 (IO8)
GPIO9: R195.2, U5.17 (IO9)
GPIO10: R196.2, U5.18 (IO10)
GPIO11: R197.2, U5.19 (IO11)
GPIO12: R109.2, U5.20 (IO12)
GPIO13: R192.2, U5.21 (IO13)
GPIO14: R201.2, U5.22 (IO14)
GPIO15: R202.2, U5.8 (IO15)
I2S2_BCLK: R192.1, R204.2
I2S2_DATA: R202.1, R203.2
I2S2_LRCLK: R201.1, U102.47 (X0D39)
I2S2_MCLK: R109.1, R205.2, R246.2
I2S_BCLK: R171.2, R194.1, U108.2 (BCLK)
I2S_DIN_ESP: R173.2, R197.1, U108.4 (DIN_/_MFP1)
I2S_DIN_SEC: R160.2, R196.1, U108.8 (SCLK_/_MFP3)
I2S_LRCK: R170.2, R193.1, U108.3 (WCLK)
I2S_MCLK: R172.2, R195.1, R246.1, U108.1 (MCLK)
MIC_CLK: R102.2, U106.12 (4A)
MIC_CLK_M: R105.1, R108.1, R209.1
MIC_DATA: U102.32 (X1D13), U106.8 (3Y)
MIC_DATA_M: R106.1, R107.2, R212.1, U106.9 (3A)
MIC_MUTE: R214.1, U5.38 (IO2)
MOSI_: R117.2, U108.10 (SDA/MOSI)
MUTE_ON: R48.1, R112.1, R214.2, U106.5 (2A), U106.10 (3~OE), U106.13 (4~OE)
N_C102_Pad1: C102.1, R104.2, X101.3
N_C119_Pad2: C119.2, R121.1
N_C120_Pad2: C120.2, R120.1
N_C121_Pad2: C121.2, R122.1
N_C164_Pad1: C164.1, R144.1, R146.2
N_C220_Pad1: C119.1, R199.2
N_C221_Pad1: C120.1, R200.2
N_Q103_G: Q103.1 (G), R129.2, R163.1
N_Q104_B: Q104.1 (B), R112.2
N_Q104_C: Q104.3 (C), R128.1, U118.3 (EN)
N_R125_Pad2: R125.2, R136.2
N_U102_PLL_AVDD: C141.1, FB106.1, U102.22 (PLL_AVDD)
N_U102_X0D11: R203.1, U102.7 (X0D11)
N_U102_X0D35: R204.1, U102.41 (X0D35)
N_U102_X0D36: R205.1, U102.43 (X0D36)
N_U102_X1D00: R160.1, U102.9 (X1D00)
N_U102_X1D01: R170.1, U102.10 (X1D01)
N_U102_X1D10: R171.1, U102.13 (X1D10)
N_U102_X1D11: R172.1, U102.14 (X1D11)
N_U102_X1D22: R102.1, U102.39 (X1D22)
N_U102_X1D34: R173.1, U102.53 (X1D34)
N_U102_XIN: C103.1, R103.2, U102.16 (XIN), X101.1
N_U102_XOUT: R103.1, R104.1, U102.15 (XOUT)
N_U104_CLK: D101.2, R209.2, U104.3 (CLK)
N_U104_DATA: D104.2, R106.2, U104.4 (DATA)
N_U105_CLK: D118.2, R105.2, U105.3 (CLK)
N_U105_DATA: D119.2, R212.2, U105.4 (DATA)
N_U105_VDD: C302.1, D112.2, R130.1, U105.1 (VDD)
N_U106_4Y: R108.2, U106.11 (4Y)
N_U108_AVDD: C133.1, C134.1, U108.24 (AVDD)
N_U108_DVDD: C137.1, C138.1, U108.29 (DVDD)
N_U108_IN1_L: C188.1, U108.13 (IN1_L), U108.14 (IN1_R)
N_U108_IN2_L: C189.1, U108.15 (IN2_L), U108.16 (IN2_R)
N_U108_IN3_L: C219.1, U108.20 (IN3_L), U108.21 (IN3_R)
N_U108_LDO__SELECT: R123.1, U108.30 (LDO__SELECT)
N_U108_LOL: R200.1, U108.22 (LOL)
N_U108_LOR: R199.1, U108.23 (LOR)
N_U108_REF: C113.1, C114.1, C187.1, U108.18 (REF)
N_U108_SPI__SELECT: R115.2, U108.12 (SPI__SELECT)
N_U109_BYPASS: C122.2, U109.2 (BYPASS)
N_U109_IN+: R122.2, U109.3 (IN+)
N_U109_IN_: R120.2, R121.2, U109.4 (IN-)
N_U109_VO+: FB105.1, U109.5 (VO+)
N_U109_VO_: FB104.1, U109.8 (VO-)
N_U110_FB: C164.2, R146.1, R147.2, U110.3 (FB)
N_U110_LX: L101.1, U110.5 (LX)
N_U111_EN: R148.2, U111.3 (EN)
N_U111_IN: C168.1, R148.1, R178.2, U111.1 (IN)
N_U112_EN: R114.2, U112.5 (EN)
N_U112_FB: C174.2, R154.1, R155.2, U112.4 (FB)
N_U112_MODE: R145.2, U112.6 (MODE)
N_U112_SW: L102.1, U112.2 (SW)
OLED_CS: J21.7, U5.25 (IO48)
OLED_DC: J21.6, U5.23 (IO21)
OLED_RES: J21.5, U5.11 (IO18)
OLED_SCL: J22.6, U5.9 (IO16)
OLED_SDA: J22.7, U5.10 (IO17)
PA_5V: C123.1, C124.1, R139.2, U109.6 (VDD)
QSPI_CLK: U102.5 (X0D10), U103.6 (CLK)
QSPI_CS_N: R101.1, U102.3 (X0D01), U103.1 (/CS)
QSPI_D0: U102.59 (X0D04), U103.5 (DI(IO0))
QSPI_D1: U102.1 (X0D05), U103.2 (DO(IO1))
QSPI_D2: U102.60 (X0D06), U103.3 (/WP(IO2))
QSPI_D3: U102.2 (X0D07), U103.7 (/HOLD(IO3))
RST_DAC: R124.1, R141.2, U108.31 (~RESET)
RST_N: C192.1, J16.6, Q103.3 (D), R131.1, U102.21 (RST_N)
R_: C301.1, D110.2, R210.1, U104.1 (VDD), U104.2 (L/R)
SCL: J22.5, R116.1, R228.1, U5.6 (IO6), U102.44 (X0D37)
SDA: J22.4, R117.1, R223.1, U5.5 (IO5), U102.45 (X0D38)
SPKM: C128.1, FB104.2, J23.1
SPKO: C127.1, FB105.2, J23.2
TCK: J16.3, U102.24 (TCK)
TDI: J16.4, U102.18 (TDI)
TDO: J16.5, U102.20 (TDO)
TMS: J16.2, U102.23 (TMS)
USB_DN: D106.2, J22.2, R156.1
USB_DP: D107.2, J22.3, R157.1
V5: C163.1, C173.1, C183.1, J21.1, R114.1, R128.2, R139.1, R145.1, R177.2, R208.2, U110.6 (IN), U112.7 (AVIN), U112.8 (PVIN), U118.4 (IN)
V09: C171.1, C172.1, C174.1, FB107.1, L102.2, R154.2
V18: C152.1, C153.1, C154.1, C169.1, C170.1, C242.1, J16.1, R131.2, U102.17 (VDDIOB18), U102.26 (VDDIOB18), U102.31 (USB_VDD18), U111.5 (OUT)
V33: C44.1, C45.1, C158.1, C165.1, C166.1, C190.1, FB108.1, FB109.1, J21.3, L101.2, R46.1, R47.1, R144.2, R159.2, R178.1, R223.2, R228.2, U5.2 (3V3), U102.30 (USB_VDD33)
V33A: C135.1, C136.1, C139.1, C140.1, C217.1, C223.1, C244.1, FB108.2, R123.2, R124.2, U108.6 (IOVDD), U108.26 (LDOIN)
VBUS_DETEC: R159.1, U102.11 (X1D09)
VDD: C143.1, C144.1, C145.1, C146.1, C147.1, C148.1, C149.1, C150.1, C151.1, FB106.2, FB107.2, U102.4 (VDD), U102.12 (VDD), U102.19 (VDD), U102.27 (VDD), U102.34 (VDD), U102.42 (VDD), U102.49 (VDD), U102.57 (VDD), U102.61 (VDD), U102.62 (VDD), U102.63 (VDD), U102.64 (VDD)
VDDIO: C101.1, C106.1, C155.1, C156.1, C157.1, C160.1, C243.1, FB109.2, R101.2, U102.8 (VDDIOL), U102.38 (VDDIOR), U102.52 (VDDIOT), U103.8 (VCC), U106.14 (VCC)
VDD_MIC: C104.1, C105.1, C112.1, C210.1, R111.2, R130.2, R210.2, U118.1 (OUT)
XOD32: R141.1, U102.56 (X0D32)
XU316_RST: R163.2, U5.4 (IO4)
__SS__: R116.2, U108.9 (SCL/~SS)

Notes on the sheet:
XU316 — Voice PE の XMOS シートの写し（CERN-OHL-P v2）
マイク 2 個（71.0mm）— Voice PE の XMOS シートの写し
コーデックとアンプ — Voice PE の DAC シートの写し
電源 0.9V・1.8V・3.3V — Voice PE の Power シートの写し
ESP32-S3-WROOM-1U とその周り
口 — ライザー（ハブへ）・スピーカー

Board: 4 copper layers, 82.0 x 34.0 mm, 185 parts (35 on the bottom side), 127 nets.

## KiCad design hardware/pcb/riser_xiao/riser_xiao.kicad_pcb

Board: 2 copper layers, 18.3 x 22.5 mm, 3 parts (1 on the bottom side), 7 nets.

Parts:
J1: L_SOCKET_1x7; J1_L_SOCKET_1x7
J2: XIAO_SIG_1x4; J2_XIAO_SIG_1x4
J3: XIAO_PWR_1x3; J3_XIAO_PWR_1x3

Connections:
BTN: J1.6, J2.1
GND: J1.2, J3.2
IN: J1.7, J2.2
SCL: J1.5, J2.4
SDA: J1.4, J2.3
V5: J1.1, J3.1
V33: J1.3, J3.3

## Code that names these connections

File hardware/pcb/v61_board.py (part):

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    #    X 並びにする羽目になっていた）。パッドの座標は動かさず、足形だけ縦に替える
    #    ⚠ 芯の Y は 8.60 → 9.00。8.60 だと枠の前端 5.85 が 取付穴 (72.5, 3.5) のナット（半径 2.56）の
    #    下へ 0.21 入る。縦にすると枠が前へ 0.35 伸びるぶんで、横出しのときは 0.14 空いていた
    ("SPK IN",      75.3,  9.00, PH2_V, "+Z", "SPKP・SPKM"),
    # 🔴 2026-09-14: ライザーが +2.87 下がって、その裏の L 字の胴が この口に 26.21mm³ 食い込んだ
    #    （筐体の実測）。後ろへ 1.9 逃がす。左向きなのは裏の電池の口に場所を譲ったため
    # ⭐ 2026-09-19: 17.1 → 17.4（+0.30）。J1 を +0.30 動かしたら枠が 0.23 重なった（前は 0.075 空き）。同じ 0.075 に戻す
    ("SPK OUT",      9.5, 17.4, PH2_H, "-X", "SPKM・SPKO"),
    # ⭐ 同上。J6 の横出しは −Y（盤面の内側）で、指の所に J1（背 8.5 のライザー）が居て、
    #    通り道が電池の下（挿し直すには電池を外す）にも当たっていた。縦にすると両方消える
    # ⭐ 2026-09-19: Y 30.00 → REAR_ROW_Y（J7 と同じ線）。30.00 は横出しの頃に −Y の通り道を取るための位置の名残だった
    ("会話ボタン",   17.5, REAR_ROW_Y, PH2_V, "+Z", "GND・BTN"),
    # 🔒 ユーザー 2026-09-19「板の後ろの縁に押しボタンを載せる方法にしようか」: ハッチのトグルをやめ、板の押しボタン（PWR_BTN）へ。
    #   J7 はリードだけになり 4 ピン → 2 ピン。芯は据え置き（4 ピンの枠 58.05〜68.95 の中に 2 ピンの枠が入る）
    # ⭐ 2026-09-19: X 63.5 → つまみの軸の芯。リードの足 2 本（芯の ±7.15）の真ん中に来る
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