# Repository n416/katanori

File README.md:

# katanori（カタノリロボ）

Gemini Live API と音声で対話する小型ロボット。**実機で会話が成立する状態まで到達済み**（2026-07-26）。
**電池で起動・会話・ミュートリレーまで通った**（2026-09-02）。

⚠ 2026-09-15 に全体を書き直した（2026-08-19 の状態のまま止まっていて、「筐体 v2 を設計中」「電池はまだ」と書いてあった）。

📖 **[かたのりの歴史](https://n416.github.io/katanori/docs/history/)** — 筐体 8 版の形と死因、燃えた・壊れた・また鏡だった事故の記録

筐体 v6.1（レジン・板 6 枚）の分解図。天板（つまみ・会話ボタン・スピーカー）・左右の壁・フロント（紫）・床の間に、
ハブ基板 katanori61・ReSpeaker Lite・OLED・電池が入る。

**組む順の当たり検査**（`hardware/tools/sweep_movie.py`・2026-09-18）— 部品を実際の入れ方で動かし、当たりを色で出す。
青＝空き・橙＝了承済みの当たり・赤＝新しい当たり。

| ハブ基板を左の窓から差す | ReSpeaker を上から降ろす | 蓋をたわませて降ろす |
|:---:|:---:|:---:|
|  |  |  |

元の mp4 と判定の表は [docs/_img/sweep/2026-09-18-nylon/](docs/_img/sweep/2026-09-18-nylon/)。

```
[ユーザーの声]
   ↓ マイク
ReSpeaker Lite (XMOS XU316, ハードウェアAEC)
   ↓ I2S
XIAO ESP32S3 ── OLED 128x64（顔の表示）
   │                └ ハブ基板（ミュートリレー・電源・INA226・つまみ AS5600）
   ↓ WebSocket over TLS
Cloudflare Durable Object（中継・音声変換）
   ↓
Gemini Live API（音声in / 音声out）
```

## 現在の状態

| 領域 | 内容 | 状態 |
|---|---|---|
| 会話の土台 | OLEDに顔を表示 | ✅ 実機確認済み |
| 会話の土台 | Wi-Fi + WSS で Durable Object へ接続 | ✅ 実機確認済み |
| 会話の土台 | DOのPCMモード・サーバ側リサンプル | ✅ デプロイ済み |
| 会話の土台 | I2S音声の送受信 | ✅ **実機で会話成立** |
| 会話の土台 | TLS証明書の検証 | ✅ 実機確認済み |
| 会話の中身 | 現在時刻の注入 | ✅ デプロイ済み |
| 会話の中身 | つなぎ言葉（応答待ちの間を埋める） | ✅ デプロイ済み |
| 会話の中身 | 起動アナウンス（焼き込み音声） | ✅ 実機確認済み（Wi-Fi接続の約1秒後に鳴る） |
| Wi-Fi | Wi-Fiプロビジョニング（キャプティブポータル） | ✅ 実機確認済み |
| Wi-Fi | 起動後のWi-Fi自動接続 | ✅ 実機確認済み |
| Wi-Fi | 繋がらないことを画面と声で伝える | ✅ 実機確認済み |
| 耳の安全 | 起動時ノイズ対策 | ✅ ソフト側（コーデックのミュートゲート）＋ **スピーカー線のミュートリレー**の 2 段。リレーは無通電で開くので、電池切れ・クラッシュ・書き込み中は物理的にスピーカーが切れる（[docs/POWER.md](docs/POWER.md) 3章） |
| 耳の安全 | **音量つまみ（AS5600・非接触の絶対角度）** | ✅ **移行完了**（2026-08-02）。可変抵抗には戻さない。「回すとコーデックが死ぬ」は原因ごと部品が消えて解消（[docs/KNOB-ENCODER.md](docs/KNOB-ENCODER.md)） |
| 耳の安全 | ミュートリレー（無通電で開） | ✅ 駆動8項目・接点 OL/0Ω 合格（2026-08-08）→ ハブ基板に実装（2026-08-18）→ **スピーカー線で動作確認**（閉→鳴る／開→鳴らない・2026-09-02） |
| 電源 | 電池駆動（電池 → PowerBoost 直結・USB なし） | ✅ 起動・完全停止・再起動まで確認（2026-09-02）。稼働時間は起きたまま・会話なしで約 2 時間 13 分（2026-09-25・[docs/POWER.md](docs/POWER.md) 6章）。ピーク電流は未実測 |
| 電源 | 電池の電圧・電流の読み取り（INA226） | ✅ 実機確認済み（2026-09-02・アドレス `0x44`） |
| 電源 | 再起動の理由を残す（`boots` / `lastlog`）・30秒のウォッチドッグ | ✅ 2026-09-12 に入れた。次に再起動が起きたらこれで見る |
| 運用 | OTA更新 | ✅ 実機確認済み（2026-08-03） |
| 運用 | 利用者の設定（画面の明るさ・眠るまでの時間・起動の声・おんりょうMAX） | ✅ 会話ボタン長押しのメニュー ＋ ブラウザの `http://katanori.local/`（2026-09-11〜12） |
| 運用 | Wi-Fi 越しのシリアルコンソール（`katanori.local` の TCP 23・OTA と同じ合言葉） | ✅ 2026-09-11。筐体に入れて USB が挿せなくてもログとコマンドが届く |
| 呼びかけ | 「カタノリ」を機体の中で聞き分ける（microWakeWord・`katanori_own_a`） | ✅ 2026-09-24 完成。映画 2 時間で誤爆 0・眠りからも起きる（[docs/WAKEUP.md](docs/WAKEUP.md)） |
| 未着手 | QRペアリング | 未着手 |

### ハードウェア（いまここ）

🔒 **現フェーズは「最小単位で動かす」** — 1台が電源から会話・安全機構まで通ること。

| | 状態 |
|---|---|
| **いまの実機** | v5 の筐体（自宅のレジン）＋ ユニバーサル基板のハブ ＋ ReSpeaker Lite ＋ XIAO。2026-09-02 に電池で起動・会話・ミュートリレーまで通った |
| **ハブ基板 v6.1（katanori61）** | ✅ 設計完了（2026-09-14）。ユニバーサル基板のハブ・PowerBoost・INA226・Type-C 基板を 1 枚に統合。DRC 0・未接続 0・`check_fab.py` 済み。**発注待ち（ユーザー判断で来月）**（[docs/PCB-V61.md](docs/PCB-V61.md)） |
| **筐体 v6.1n（MJF ナイロン・一体シェル）** | ✅ 設計完了・発注用 STL 7 点を書き出し済み（2026-09-15・`hardware/stl/v61n/`・バイナリ STL）。MJF の判定（`_stl_preflight.py --mat nylon`）で 🔴 0（[docs/CASE-V61N.md](docs/CASE-V61N.md) 5.1）。SOLIZE の自動見積りが「シェル数 129」で弾いた二重面は 2026-09-16 に直してシェルと天板を書き出し直した（同 5.3）。同日、壁厚に連動して R 1.6 に縮んでいた稜の丸みを R 2.0 に固定し、内側の角にも同心の R 0.4 を足して再度書き出した（同 5.4）。**発注待ち** |
| **筐体 v6.1（レジン・板 6 枚）** | v6.1n の元。刷らない（全部 MJF に決めた・2026-09-15） |
| **つまみ** | v6.1n で MJF・E リング 2 枚。⚠ E リングを実物で嵌めた記録はまだ無い |
| **自前の音声の板（ReSpeaker Lite ＋ XIAO の置き換え）** | ⏸ 保留（2026-09-15・量産の計画が立ったら再開）。[docs/VOICE-BOARD.md](docs/VOICE-BOARD.md) 0 章 |

**残りの全量は [docs/TODO.md](docs/TODO.md) にフェーズ順で集約してある。**

Wi-Fi未設定の機体を渡せば、スマホでQRを読む → 設定画面が自動で開く → 設定 → 会話、
という流れが通ります。設定済みの機体は、電源を入れるだけで自動でWi-Fiへ繋ぎ、
ボタンを押した時点でサーバーへ接続します（シリアルコンソールは不要）。

## リポジトリ構成

```
firmware/
├── core/          純C++14のコアロジック。Arduino依存禁止。実機とシミュレーターで共有
│                  DisplayBuffer / StateMachine / Face / RobotCore
├── hal/           IHal.h（プラットフォーム抽象）
├── esp32/         実機ファームウェア（PlatformIO）   ★詳細は firmware/esp32/README.md
│   └── src/       main.cpp / NetLink / AudioIo / Provisioning / RootCa.h
│                  Battery（INA226）/ BootLog（再起動の理由・ウォッチドッグ）/ Console（Wi-Fi 越しのシリアル）
│                  Settings（利用者の設定・katanori.local の設定ページ）/ VoiceClips.h（焼き込み音声・自動生成）
├── serlog.py      実機のシリアルを読み続けてログに落とし、cmd.txt からコマンドも送る道具
└── blank/ i2sprobe/ xmosver/   切り分け用の小さなファーム（空スケッチ＝発熱の切り分け／I2S の探り針／XMOS ファームの版数読み取り）

katanori-backend/  Cloudflare Worker + Durable Object  ★詳細は katanori-backend/README.md
├── src/           index.ts（中継とプロトコル）/ resample.ts（24k→16k）/ fillers.ts（つなぎ言葉の音源）
└── tools/         gen-fillers.mjs（つなぎ言葉）/ gen-voice-clips.mjs（実機の焼き込み音声 → VoiceClips.h）/ tts.mjs

simulator/         Windows用シミュレーター（Win32 GDI、外部lib不要）
├── win32/         main_win32.cpp
├── wrapper.py     PC上でマイク・スピーカー・DO接続を担うPythonラッパー
└── tuner.html     ロボットボイスの調整UI

hardware/          筐体・つまみ・基板の CAD（OpenSCAD）。直下の .scad は case_v5（いまの実機）・case_v6_1（レジン）・case_v6_1n（MJF・現行）
├── pcb/           KiCad の板（katanori61/ ＝ v6.1 のハブ・発注待ち。katanori61_audio/・_hub/ は保留中の音声の板）と、
│                  回路図 → 配置 → 自動配線 → 製造ファイル → 検算のスクリプト。読み方は docs/PCB-V61.md
├── parts/         部品ライブラリ（parts.scad / respeaker_lite.scad / knob_v61n・spk_v61n・btn_v61n ほか。
│                  relay_board.html ＝ いまの実機のハブ基板の穴割り）
├── icons/         刻印の元絵（SVG）と生成スクリプト
├── tools/         刷る前の検算（_stl_preflight.py は `--mat resin|nylon` で判定が変わる・stl/v61n は自動で nylon ／ _stl_clean.py）
│                  書き出し（stl_v5.py / stl_v61n.py。--check で筐体の当たり検査）／ stl_bin.py（ASCII STL → バイナリ）
├── stl/           印刷した STL（刷るぞーが読む）。v61n/ は MJF 発注用の 7 点
├── print_log.jsonl 印刷の記録（刷るぞーが書く）
├── concepts/      2026-09-13 の並べ替え案 A〜E（docs/CONCEPTS-2026-09-13.md）
├── ref/           実物の写真・ピン配置・データシート
├── sim/           MuJoCo の模型（m2_sorter/ ＝ M2 ねじ仕分けの機構、2026-09-07）
├── frozen/v1-v4/  🔒 凍結した v1〜v4 の .scad・検算・レンダー。読まない・触らない
└── frozen/v6/     v6（2026-09-12〜13・失敗）。歯車の機構と KiCad の板は次で使い回す。中身は frozen/v6/README.md

surugo/            刷るぞー — 印刷ターム（プレート 1 枚）単位で計画を立て、結果を print_log.jsonl に積む道具

docs/              設計と記録。入口は次の表
docs/manual/       組み立てマニュアル（assembly_v5.html がいまの実機。v3・v4 は履歴）
docs/history/      かたのりの歴史ページ（index.html。筐体 v1〜v6.1n と中身の節目、事故と失敗）
SPEC.md            シミュレーターの仕様
SPEC_SIM.md        同上（詳細）
仕様書.md           yorisoi-care-app との統合仕様（全体構想）
```

### docs/ の読み方

| 知りたいこと | 文書 |
|---|---|
| 何が残っているか（フェーズ順） | [docs/TODO.md](docs/TODO.md) |
| いちばん上の決定（音声モジュールとアプリの分離） | [docs/ARCHITECTURE.md](docs/ARCHITECTURE.md) |
| 現行の筐体 v6.1n（MJF）の形・検査・発注 | [docs/CASE-V61N.md](docs/CASE-V61N.md) |
| 現行のハブ基板 v6.1 に載る物 | [docs/PCB-V61.md](docs/PCB-V61.md) |
| 電源・ミュートリレー・電池 | [docs/POWER.md](docs/POWER.md) |
| 机の上で初めて電源を入れる手順 | [docs/FIRST-RUN.md](docs/FIRST-RUN.md) |
| つまみ（AS5600） | [docs/KNOB-ENCODER.md](docs/KNOB-ENCODER.md) |
| ReSpeaker Lite の形と結線 | [docs/RESPEAKER-LITE.md](docs/RESPEAKER-LITE.md) |
| 部品の寸法と出どころ | [docs/DIMENSIONS.md](docs/DIMENSIONS.md) |
| 3D プリンタ（レジン）と MJF の数字 | [docs/PRINT.md](docs/PRINT.md) |
| シミュレーター | [docs/SIMULATOR.md](docs/SIMULATOR.md) |
| 呼びかけ（ウェイクワード） | [docs/WAKEUP.md](docs/WAKEUP.md) |
| 保留中の自前の音声の板 | [docs/VOICE-BOARD.md](docs/VOICE-BOARD.md) |
| 打ち切った筐体の記録（v2〜v6） | CASE-V2 / V3 / V4* / V5-PLAN / V6-PLAN |

## 動かし方

### 実機

```bash
cd firmware/esp32
pio run -e xiao_esp32s3 -t upload
pio device monitor -e xiao_esp32s3 --port COM4   # ポートは pio device list で確認
```

ポート番号はPCごとに変わります（この機体は環境によって COM3〜COM5 になっています）。
USBドライバは不要です（ネイティブUSBなので挿すだけで見えます）。

シリアルで `?` を打つとコマンド一覧が出ます。会話は `wifi` → `c` → `1`（喋る）。
抜き差しの多い作業では `python firmware/serlog.py` がポートを待ち続けてログに落とします。
筐体に入れて USB が挿せないときは、同じ Wi-Fi から `katanori.local` の TCP 23 番（telnet・PuTTY の Raw）で
同じコンソールが使えます。2 回目からは `pio run -e xiao_esp32s3_ota -t upload` で Wi-Fi 越しに焼けます。
**詳細・配線・トラブルシューティングは [firmware/esp32/README.md](firmware/esp32/README.md)。**

### バックエンド

```bash
cd katanori-backend
npm install
npm run deploy
```

**プロトコルの詳細は [katanori-backend/README.md](katanori-backend/README.md)。**

### シミュレーター（PC単体で顔と会話を試す）

```bash
# w64devkit を PATH に前置してから
simulator\build.bat
python simulator\wrapper.py
```

顔は実機と同じ `firmware/core` が描き、DOへの接続も実機と同じPCMバイナリモード
（`?voice=Achird&pcm=16000`）を使います。**バックエンドやプロンプトの変更は、
実機へ焼く前にここで確かめられます。** 一方 I2S・AEC・Wi-Fi は実機でしか出ません。
**詳細は [docs/SIMULATOR.md](docs/SIMULATOR.md)。**

## 実機で判明した重要な事実

公式ドキュメントに書かれておらず、実機で踏んで初めて分かったものです。
**同じ罠を二度踏まないよう、詳細は各READMEに記録してあります。**

| 事実 | 詳細 |
|---|---|
| I2Sは **ESP32がスレーブ・32bitスロット**（公式サンプルはマスタ・16bit） | firmware/esp32/README.md |
| XIAO ESP32S3 は**外付けアンテナ必須**（未接続でRSSIが40dB悪化） | 同上 |
| **GPIO43 = UART0 TX = I2S DOUT**。リセット時のブートログが轟音になる | 同上 |
| **`D10`(GPIO9) は ReSpeaker Lite 側が握っている**。ミュートリレーの駆動に使うと電源投入時に閉じっぱなしになる。駆動は `D3`(GPIO4) | 同上 |
| **`D1`(GPIO2) は XMOS のリセット線**。`pinMode` 禁止 | docs/TODO.md A-4 |
| WebSocketライブラリは **15KB超のフレームで無言切断**（DO側で4KBに刻む） | katanori-backend/README.md |
| Geminiの応答は**バイナリフレーム**で届く（中身はJSON） | 同上 |
| プロビジョニングは **STA停止→スキャン→AP起動** の順でないとAPが電波に出ない | firmware/esp32/README.md |
| **スキャンでSSIDの有無は判定できない**（ステルスAPが1つでもあると「一覧に無い＝無い」が成立しない）。接続の切断理由コードを見るほうが速く確か | firmware/esp32/README.md |
| **I2Sへの直接書きは鳴らない**。再生タスクが無音を流し続ける方式のため、キュー経由以外はDMAの取り合いに負ける（beepがこれで壊れていた） | AudioIo.cpp の toneTest コメント |
| **AS5600 の GND が繋がっていないと I2C バスごと固まる**（つまみだけでなく OLED も出ない） | docs/FIRST-RUN.md「詰まったときの見分け」 |
| **XIAO の `5V` を `D10`(I2S_MCLK) に挿すとコーデックが設定されない**（音が出ないが壊れない） | 同上 |
| **INA226 のアドレスは `0x44`**（モジュールの初期値 `0x40` ではない） | firmware/esp32/src/Battery.h |

## 未着手の一覧

会話は動くが、**自立ロボットとしての土台（筐体・認証）がまだ空白**。
何が無いかは **[docs/TODO.md](docs/TODO.md)** に集約してある。
🔒 **A章＝現フェーズ（最小単位で動かす）／ B章＝人に渡す ／ C章＝フェーズ2（Stackchan）** の順で並ぶ。

## 次にやること

🔒 **いまはハードウェアの段である。ソフトの新機能は現フェーズに入っていない。**

1. **発注**（[docs/TODO.md](docs/TODO.md) A 章）— ハブ基板 v6.1 を JLCPCB へ、筐体 v6.1n の MJF 7 点を JLC3DP へ、一緒に出す
   （ユーザー判断で来月。出す前に `hardware/pcb/check_fab.py` で在庫と価格を取り直す）
2. **ピーク電流の実測**（スピーカーが鳴った瞬間）— 次の板の昇圧を 1A にできるかの決め手
3. **音量の上限を耳で決める** — 天井 0.70 はイヤホンの頃の値。下げるだけなら設定の「おんりょうMAX」
4. **届いたら組み替える** — E リングを実物で嵌める

**その先（人に渡すため）**: 肩への固定・重量 → 認証・費用の上限・QRペアリング → 実使用者テスト。
**フェーズ2**: 遠隔モジュール（Stackchan）を BLE で足す（[docs/ARCHITECTURE.md](docs/ARCHITECTURE.md)）。

呼びかけ（「カタノリ」固定）は機体の中で聞き分けて動く。2026-09-24 に own_a で完成
（[docs/WAKEUP.md](docs/WAKEUP.md)）。⬜ **保留中**: 証明書の有効期限検証は
`CONFIG_MBEDTLS_HAVE_TIME_DATE` が無効で未検証だが、ピン留め済みなので実害は薄い。
自前の音声の板は量産の計画が立つまで保留（[docs/VOICE-BOARD.md](docs/VOICE-BOARD.md)）。

### 済んだもの

- **時刻の注入**（2026-07-26）— LLMは時計を持たず、聞かれると嘘の日時を答えていた。
  DO側で接続時に日本時間を systemInstruction へ埋める（`buildSystemInstruction()`）。
  Workers の `Date` は常にUTCなので `timeZone: "Asia/Tokyo"` の明示が必須。
- **つなぎ言葉**（2026-07-26）— 応答までの1.3秒の沈黙を埋める。DO側で完結し、
  ファームの変更は不要（`audioStreamEnd` を受けた時点で音声を先に返す）。
  音源は `katanori-backend/tools/gen-fillers.mjs` でTTS生成し `src/fillers.ts` に格納。
  **声名は実機が要求している `Achird` に合わせること**（DO既定値の `Aoede` で焼いて
  別人になった経緯あり）。詳細は katanori-backend/README.md。
- **ミュートリレー**（2026-08-03 決定 → 2026-08-08 駆動合格 → 2026-09-02 スピーカー線で確認）—
  再生中の電池切れ・ブラウンアウトで ROM ブートログが耳元で鳴る経路を、ソフトではなく接点で塞いだ。
  無通電で開くので、ファームが守っているのは「普段どおり動いているときに閉じる」だけ（[docs/POWER.md](docs/POWER.md) 3章）。
- **電池駆動**（2026-08-01 旧ボードで 20 分 → 2026-09-02 現行機で起動・完全停止・再起動）。
- **再起動の理由を残す**（2026-09-12）— 2026-09-11 夜の勝手な再起動で理由が何も残らなかったため。
  リセットの理由と直前 1 秒ごとの様子を RTC メモリに、前回の最後のログ約 3KB を `lastlog` で。固まったら 30 秒で再起動。

## 既知の弱点

- **設定用APは開放（暗号化なし）でページもHTTP。** 入力されたWi-Fiパスワードは
  設定中の数分間、近くの第三者から傍受されうる。市販IoT機器でも一般的な方式だが弱点。
- **設定ページ（`katanori.local`）に合言葉が無い。** 同じ LAN の他人が明るさや音量の上限を変えられる。
  上限より上には上げられないので耳は傷めない（Wi-Fi 越しのコンソールは OTA と同じ合言葉を最初の 1 行で求める）。
- **ルートCAをピン留めしている。** 接続先が発行元CAを変更すると繋がらなくなる。
  更新手順は `firmware/esp32/src/RootCa.h` のコメント参照。
- **耳元の音圧の上限はミュートリレーが担っている。** 再生中のクラッシュ・電池切れ・ブラウンアウトで
  コーデックが解除のまま残っても、コイルが落ちれば接点が開いてスピーカーは切れる（2026-09-02 実機確認）。
  ⚠ 接点が溶着した場合は守れない。v6 で「2 極目を使い、接点 1 つが溶着してもスピーカーの回路が切れる形にする」と決めた
  （[docs/POWER.md](docs/POWER.md)）。v6.1 の板のリレーは 2 極（G6S-2F）だが、そう配線してあるかは [docs/PCB-V61.md](docs/PCB-V61.md) に書いていない。
  音圧そのものの上限（WHO-ITU H.870 / EN 50332）は未調査。
- **勝手に再起動する**（2026-09-11・原因未特定）。起動の声が 5〜15 分おきに鳴り、電池を使い切った。2026-09-24 にユーザー判断で追わないことにした（クローズ）。2026-09-25 の稼働時間の実測で、電池が減ると同じ形でブラウンアウトの再起動を繰り返すのを見た（[docs/POWER.md](docs/POWER.md) 6章）。
  次に起きたら `boots` / `lastlog` で理由が読める。

## KiCad design hardware/pcb/katanori61/katanori61.kicad_pcb

Parts:
C1, C7, C8: 10uF; C_0805_2012Metric; LCSC C15850
C2: 2.2uF; C_0805_2012Metric; LCSC C377773
C4, C31, C32, C41, C42: 0.1uF; C_0805_2012Metric; LCSC C49678
C6, C9: 47uF; C_1206_3216Metric; LCSC C96123
D31: 1N4148W; D_SOD-123; LCSC C81598
J1: XIAO RISER; PinHeader_1x07_P2.54mm_Vertical
J2: OLED; PinHeader_1x04_P2.54mm_Vertical
J4: SPK IN; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J5: SPK OUT; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J6: BTN2; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J7: REED; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J10: BAT (JST-PH); JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J13: USB-C; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
K31: G6S-2F DC5; Relay_DPDT_Omron_G6S-2F; LCSC C16707
L1: 6.8uH; L_Changjiang_FNR4018S; LCSC C167807
Q2: AO3401A; SOT-23; LCSC C15127
Q31: SS8050; SOT-23; LCSC C2150
R3: 1.87M; R_0805_2012Metric; LCSC C482988
R4, R13: 200K; R_0805_2012Metric; LCSC C17539
R6: 220K; R_0603_1608Metric; LCSC C22961
R7: 82K; R_0603_1608Metric; LCSC C23254
R15: 15K; R_0805_2012Metric; LCSC C17475
R16: 1.0K; R_0805_2012Metric; LCSC C17513
R17, R46: 100K; R_0805_2012Metric; LCSC C149504
R31: 1k; R_0805_2012Metric; LCSC C17513
R32: 10k; R_0805_2012Metric; LCSC C17414
R41: 10m; R_1206_3216Metric; LCSC C105362
R42, R43: 10K; R_0805_2012Metric; LCSC C17414
R44, R45: 5.1k; R_0805_2012Metric; LCSC C27834
SW2: XKB5858-Z-E; SW_XKB5858-Z-E; LCSC C780038
U1: TPS61090RSAR; Texas_RSA_VQFN-16-1EP_4x4mm_P0.65mm_EP2.7x2.7mm; LCSC C206167
U2: MCP73871-2CCI/ML; QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm; LCSC C511310
U3: INA226AIDGSR; TSSOP-10_3x3mm_P0.5mm; LCSC C49851
U4: AS5600-ASOT; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C499458

Connections:
BASE: Q31.1 (B), R31.2, R32.1
BATG: Q2.1 (G), R46.1
BATP: Q2.2 (S), R41.1, U3.10 (Vin+)
BATRAW: J10.2, Q2.3 (D)
BTN: J1.6, J6.2
CC1: J13.A5 (CC1), R44.1
CC2: J13.B5 (CC2), R45.1
COL: D31.2 (A), K31.12, Q31.3 (C)
EN: C32.1, J7.1, R13.2, SW2.3 (NO_A), U1.11 (EN)
FB: R3.2, R4.1, U1.14 (FB)
GND: C1.2, C2.2, C4.2, C6.2, C7.2, C8.2, C9.2, C31.2, C32.2, C41.2, C42.2, J1.2, J2.1, J6.1, J7.2, J10.1, J13.A1 (GND), J13.A12 (GND), J13.B1 (GND), J13.B12 (GND), J13.SH (SHIELD), Q31.2 (E), R4.2, R7.2, R15.1, R16.1, R17.1, R32.2, R44.2, R45.2, R46.2, SW2.1 (NC_A), U1.5 (PGND), U1.6 (PGND), U1.7 (PGND), U1.9 (LBI), U1.10 (SYNC), U1.13 (GND), U1.17 (PAD), U2.10 (V_{SS}), U2.11 (V_{SS}), U2.21 (V_{SS}), U3.2 (A0), U3.7 (GND), U4.4 (GND), U4.8 (DIR)
IN: J1.7, R31.1
PROG1: R16.2, U2.13 (PROG1)
PROG3: R17.2, U2.12 (PROG3)
SCL: J1.5, J2.3, R43.2, U3.5 (SCL), U4.7 (SCL)
SDA: J1.4, J2.4, R42.2, U3.4 (SDA), U4.6 (SDA)
SPKM: J4.2, J5.1
SPKO: J5.2, K31.5
SPKP: J4.1, K31.4
SW: L1.2, U1.3 (SW), U1.4 (SW)
THERM: R15.2, U2.5 (THERM)
V5: C2.1, C6.1, C9.1, C31.1, D31.1 (K), J1.1, K31.1, R3.1, U1.1 (VOUT), U1.15 (VOUT), U1.16 (VOUT)
V33: C41.1, C42.1, J1.3, J2.2, R42.1, R43.1, U3.1 (A1), U3.6 (VS), U4.1 (VDD5V), U4.2 (VDD3V3)
VBUS: C8.1, J13.A4 (VBUS), J13.A9 (VBUS), J13.B4 (VBUS), J13.B9 (VBUS), R6.1, U2.3 (SEL), U2.4 (PROG2), U2.9 (~TE), U2.17 (CE), U2.18 (IN), U2.19 (IN)
VLIPO: C7.1, R41.2, U2.14 (V_{BAT}), U2.15 (V_{BAT}), U2.16 (V_{BAT_SENSE}), U3.8 (Vbus), U3.9 (Vin-)
VPCC: R6.2, R7.1, U2.2 (VPCC)
VSYS: C1.1, C4.1, L1.1, R13.1, U1.8 (VBAT), U2.1 (OUT), U2.20 (OUT)

Notes on the sheet:
昇圧 — Adafruit PowerBoost 1000C Rev B の写し（CC BY-SA 3.0・Limor Fried / Adafruit）
充電 — 同じく PowerBoost 1000C Rev B の写し
電流計 — INA226（シャント 10mΩ・0x44）・電池と USB の口
ハブ — relay_board.html のミュートリレー・会話ボタン
口 — hub_ports.py の並びのまま（今の線がそのまま挿さる）

Board: 4 copper layers, 82.0 x 37.4 mm, 45 parts (1 on the bottom side), 27 nets.

File hardware/pcb/katanori61/fab/bom.csv:

Comment,Designator,Footprint,JLCPCB Part #
10uF,"C1,C7,C8",C_0805_2012Metric,C15850
2.2uF,C2,C_0805_2012Metric,C377773
0.1uF,"C31,C32,C4,C41,C42",C_0805_2012Metric,C49678
47uF,"C6,C9",C_1206_3216Metric,C96123
1N4148W,D31,D_SOD-123,C81598
USB-C,J13,USB_C_Receptacle_HRO_TYPE-C-31-M-12,C165948
G6S-2F DC5,K31,Relay_DPDT_Omron_G6S-2F,C16707
6.8uH,L1,L_Changjiang_FNR4018S,C167807
AO3401A,Q2,SOT-23,C15127
SS8050,Q31,SOT-23,C2150
15K,R15,R_0805_2012Metric,C17475
1.0K,"R16,R31",R_0805_2012Metric,C17513
1.87M,R3,R_0805_2012Metric,C482988
200K,"R13,R4",R_0805_2012Metric,C17539
10m,R41,R_1206_3216Metric,C105362
10K,"R32,R42,R43",R_0805_2012Metric,C17414
5.1k,"R44,R45",R_0805_2012Metric,C27834
100K,"R17,R46",R_0805_2012Metric,C149504
220K,R6,R_0603_1608Metric,C22961
82K,R7,R_0603_1608Metric,C23254
TPS61090RSAR,U1,Texas_RSA_VQFN-16-1EP_4x4mm_P0.65mm_EP2.7x2.7mm,C206167
MCP73871-2CCI/ML,U2,QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm,C511310
INA226AIDGSR,U3,TSSOP-10_3x3mm_P0.5mm,C49851
AS5600-ASOT,U4,SOIC-8_3.9x4.9mm_P1.27mm,C499458
